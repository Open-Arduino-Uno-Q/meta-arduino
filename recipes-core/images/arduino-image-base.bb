require recipes-core/images/core-image-base.bb

SUMMARY = "arduino uno q base image"

IMAGE_INSTALL += "abseil-cpp android-tools android-tools-adbd"
